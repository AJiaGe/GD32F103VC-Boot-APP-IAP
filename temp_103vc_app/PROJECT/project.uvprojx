# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\CMSIS;..\PROJECT;..\STDLIB\Include;..\USER;..\SEGGER_RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: startup_gd32f10x_hd.s system_gd32f10x.c
  group PROJECT
    ./: main.c systick.c
  group STDLIB
    ../STDLIB/Source/: gd32f10x_gpio.c gd32f10x_rcu.c gd32f10x_misc.c gd32f10x_dma.c gd32f10x_usart.c gd32f10x_i2c.c gd32f10x_exmc.c gd32f10x_fmc.c gd32f10x_timer.c
  group USER
    ../USER/: usart0.c iic.c led.c exmc.c lcd.c xpt2046.c fmc.c tim.c at24cxx.c
  group SEGGER_RTT
    ../SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
